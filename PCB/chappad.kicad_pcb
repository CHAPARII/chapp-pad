# Repository CHAPARII/chapp-pad

File README.md:

# ChapPad
I've madee this hackpad by my experience which I've gained while working on my keyboard :b. Also by making this I'll add this hackpad in my setup with the keyboard!! 

This hackpad have 11keys and 1 rotary encoder, I've used XIAO RP2040 microcontroller in this and a 0.9'' OLED Display. I've done the BOM and made it from one supplier "Amazon" to make clean or else it could become messy. I've some keys in my home as well (1-2 keys) which I'll use in if it's needed. :b For the CAD I made it in two parts "top" and "bottom". I also thought to make a top plate but that would look over artificial and I wanted my Hackpad to look like "YES!! This is coustom hackpad, which I made by myself". I'll order the PCB in red or blue color because will match with my setup T_T.. wuuhuuuu I'm so exited to build this!!!

The CAD designe is looking preety simple (as I made it intentionally), but the PCB became so rocking cool!!

Till now everything is good to go! yay!

# Images

## Bill of Materials (BOM)

| Item | Purpose | Qty | Total Price (USD) | Purchase Link | Distributor |
|------|---------|----:|------------------:|---------------|-------------|
| XIAO RP2040 | Microcontroller | 1 | $10.83 | https://www.amazon.in/ | Amazon |
| MX Mechanical Switches | Hackpad Switches | 10 | $2.75 | https://www.amazon.in/ | Amazon |
| Rotary Encoder | Rotary Encoder | 2 | $1.83 | https://www.amazon.in/ | Amazon |
| 0.91" OLED Display | Display | 1 | $2.65 | https://www.amazon.in/ | Amazon |
| 1N4148 Diodes | Diodes | 1 | $2.65 | https://www.amazon.in/ | Amazon |
| Blank DSA Keycaps | Keycaps | 12 | $6.45 | https://www.amazon.in/ | Amazon |
| PCB | PCB | 1 | $12.34 | N/A | JLCPCB |

### Tax

**$5.00 USD**

### Total Cost

**≈ $44.50 USD**

## KiCad design PCB/chappad.kicad_pcb

Board: 2 copper layers, 95.8 x 85.5 mm, 30 parts (9 on the bottom side), 25 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: OLED_128x32
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11: SW_Push_45deg; MX_PCB_1.00u
SW12: RotaryEncoder_Switch_MP; Encoder_EC11_MX
U1: XIAO-RP2040-DIP

Connections:
+5V: J1.2 (VCC), U1.14 (VBUS)
Col 0: SW1.1, SW4.1, SW7.1, SW10.1, U1.7 (GPIO0/TX)
Col 1: SW2.1, SW5.1, SW8.1, SW11.1, U1.8 (GPIO1/RX)
Col 2: SW3.1, SW6.1, SW9.1, SW12.S1, U1.9 (GPIO2/SCK)
Encoder A: SW12.A, U1.11 (GPIO3/MOSI)
Encoder B: SW12.B, U1.10 (GPIO4/MISO)
GND: H1.1, H2.1, H3.1, H4.1, J1.1 (GND), SW12.C, SW12.MP, U1.13 (GND)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.S2
unnamed: J1.3 (SCL), U1.6 (GPIO7/SCL)
unnamed: J1.4 (SDA), U1.5 (GPIO6/SDA)
Row 0: D1.1 (K), D2.1 (K), D3.1 (K), U1.4 (GPIO29/ADC3/A3)
Row 1: D4.1 (K), D5.1 (K), D6.1 (K), U1.3 (GPIO28/ADC2/A2)
Row 2: D7.1 (K), D8.1 (K), D9.1 (K), U1.2 (GPIO27/ADC1/A1)
Row 3: D10.1 (K), D11.1 (K), D12.1 (K), U1.1 (GPIO26/ADC0/A0)

## Commit log

2026-06-29 Create temp
2026-06-29 Create GBR
2026-06-29 Create Production
